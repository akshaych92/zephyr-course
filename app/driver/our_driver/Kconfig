## app/driver/our_driver/Kconfig
```kconfig
config OUR_DRIVER
    bool "Our Driver"
    default y
    help
      Enable support for our driver.
```
